Commit message: Update URDF.

File: src/vision/perception/description.urdf (robot description, URDF)
Before this commit: robot han, 12 links, 11 joints
Joints:
- joint body_camera: origin xyz=1.5 0 0.7 rpy=0 0 0 -> xyz=0.15 0 0.45 rpy=0 -0.6 0
